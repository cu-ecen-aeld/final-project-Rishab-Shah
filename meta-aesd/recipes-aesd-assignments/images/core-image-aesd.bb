inherit core-image
IMAGE_INSTALL_append = " aesd-assignments"
#inherit extrausers
#EXTRA_USERS_PARAMS = "usermod -P root root;"
